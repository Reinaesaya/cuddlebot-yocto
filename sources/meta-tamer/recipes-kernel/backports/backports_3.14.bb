include backports.inc

SRC_URI[md5sum] = "14bb1d250d101d0c7dec75d4a17228fe"
SRC_URI[sha256sum] = "bb6e5dc5d59c60b7fd053da3b16c0081d7f9de5b539ffc297feb505629f24095"
