include hostap-daemon.inc

SRC_URI[md5sum] = "23c1f78a693c3288802d516adb7fd289"
SRC_URI[sha256sum] = "f15b6bcb434378860ea5b88dffed7f54d8cb71fff2146de0f006977a5e25a882"
