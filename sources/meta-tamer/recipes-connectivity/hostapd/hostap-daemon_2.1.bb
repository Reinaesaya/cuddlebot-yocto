include hostap-daemon.inc

SRC_URI[md5sum] = "bb9c50e87c5af6f89f387e63911effac"
SRC_URI[sha256sum] = "5c7110f55b6092e5277e26edc961eda2def12b94218129d116f5681e34bb2f88"
